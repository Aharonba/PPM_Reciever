options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: audio_volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: |-
      Static center frequency, slightly offsetted
      from the PMR446 band
    value: 446.2E6
  states: {}
- name: chan_freq_base
  id: variable
  parameters:
    value: 446.00625E6
  states: {}
- name: chan_width
  id: variable
  parameters:
    value: 12.5E3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      The sampling frequency is set to
      1.2MS/s + a little extra in order to "synch"
      the RF recevier clock with the DAC.
      By speeding up the RF sampling we can
      avoid audio underruns (uA).
      This value must be tuned for different hw.
    value: 1.2E6 + samp_rate_compensation
  states: {}
- name: samp_rate_compensation
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: sql
  id: variable_qtgui_range
  parameters:
    label: Squelch Threshold
    start: '-100'
    step: '1'
    stop: '0'
    value: '-18'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48E3)
    comment: PMR446 uses NBFM modulation
    max_dev: 5e3
    quad_rate: int(480E3)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48E3)
    comment: PMR446 uses NBFM modulation
    max_dev: 5e3
    quad_rate: int(480E3)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48E3)
    comment: PMR446 uses NBFM modulation
    max_dev: 5e3
    quad_rate: int(480E3)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_1
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48E3)
    comment: PMR446 uses NBFM modulation
    max_dev: 5e3
    quad_rate: int(480E3)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_2
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48E3)
    comment: PMR446 uses NBFM modulation
    max_dev: 5e3
    quad_rate: int(480E3)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_3
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48E3)
    comment: PMR446 uses NBFM modulation
    max_dev: 5e3
    quad_rate: int(480E3)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_4
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48E3)
    comment: PMR446 uses NBFM modulation
    max_dev: 5e3
    quad_rate: int(480E3)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_4_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48E3)
    comment: PMR446 uses NBFM modulation
    max_dev: 5e3
    quad_rate: int(480E3)
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '0'
    threshold: sql
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '0'
    threshold: sql
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '0'
    threshold: sql
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '0'
    threshold: sql
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_2
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '0'
    threshold: sql
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_3
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '0'
    threshold: sql
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_4
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '0'
    threshold: sql
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_4_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '0'
    threshold: sql
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq - (chan_freq_base + (1 - 1)*chan_width)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '8'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_3
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_4
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_4_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: mixer
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /Users/aharon/Desktop/לימודים/שנה ג/סמסטר ב/מבוא לרדיו תוכנה/מטלה 1/Audio_record.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '12500'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 12500*2
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 12500*3
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 12500*4
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 12500*5
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_4
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 12500*6
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_4_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 12500*7
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5E3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5E3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5E3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5E3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5E3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5E3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 5E3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5E3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: 5E3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5E3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_3
  id: low_pass_filter
  parameters:
    cutoff_freq: 5E3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5E3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_4
  id: low_pass_filter
  parameters:
    cutoff_freq: 5E3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5E3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_4_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5E3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5E3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_3
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_4
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_4_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_nbfm_rx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_nbfm_rx_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [analog_nbfm_rx_0_0_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [analog_nbfm_rx_0_0_2, '0', blocks_multiply_const_vxx_0_0_2, '0']
- [analog_nbfm_rx_0_0_3, '0', blocks_multiply_const_vxx_0_0_3, '0']
- [analog_nbfm_rx_0_0_4, '0', blocks_multiply_const_vxx_0_0_4, '0']
- [analog_nbfm_rx_0_0_4_0, '0', blocks_multiply_const_vxx_0_0_4_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', analog_nbfm_rx_0_0, '0']
- [analog_pwr_squelch_xx_0_0_0, '0', analog_nbfm_rx_0_0_0, '0']
- [analog_pwr_squelch_xx_0_0_1, '0', analog_nbfm_rx_0_0_1, '0']
- [analog_pwr_squelch_xx_0_0_2, '0', analog_nbfm_rx_0_0_2, '0']
- [analog_pwr_squelch_xx_0_0_3, '0', analog_nbfm_rx_0_0_3, '0']
- [analog_pwr_squelch_xx_0_0_4, '0', analog_nbfm_rx_0_0_4, '0']
- [analog_pwr_squelch_xx_0_0_4_0, '0', analog_nbfm_rx_0_0_4_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_0_2, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_0_0_3, '0', blocks_add_xx_0, '5']
- [blocks_multiply_const_vxx_0_0_4, '0', blocks_add_xx_0, '6']
- [blocks_multiply_const_vxx_0_0_4_0, '0', blocks_add_xx_0, '7']
- [blocks_multiply_xx_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_multiply_xx_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_multiply_xx_0, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [blocks_multiply_xx_0, '0', freq_xlating_fir_filter_xxx_0_0_2, '0']
- [blocks_multiply_xx_0, '0', freq_xlating_fir_filter_xxx_0_0_3, '0']
- [blocks_multiply_xx_0, '0', freq_xlating_fir_filter_xxx_0_0_4, '0']
- [blocks_multiply_xx_0, '0', freq_xlating_fir_filter_xxx_0_0_4_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', low_pass_filter_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', low_pass_filter_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', low_pass_filter_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_2, '0', low_pass_filter_0_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_3, '0', low_pass_filter_0_0_3, '0']
- [freq_xlating_fir_filter_xxx_0_0_4, '0', low_pass_filter_0_0_4, '0']
- [freq_xlating_fir_filter_xxx_0_0_4_0, '0', low_pass_filter_0_0_4_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [low_pass_filter_0_0_1, '0', rational_resampler_xxx_0_0_1, '0']
- [low_pass_filter_0_0_2, '0', rational_resampler_xxx_0_0_2, '0']
- [low_pass_filter_0_0_3, '0', rational_resampler_xxx_0_0_3, '0']
- [low_pass_filter_0_0_4, '0', rational_resampler_xxx_0_0_4, '0']
- [low_pass_filter_0_0_4_0, '0', rational_resampler_xxx_0_0_4_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', analog_pwr_squelch_xx_0_0_0, '0']
- [rational_resampler_xxx_0_0_1, '0', analog_pwr_squelch_xx_0_0_1, '0']
- [rational_resampler_xxx_0_0_2, '0', analog_pwr_squelch_xx_0_0_2, '0']
- [rational_resampler_xxx_0_0_3, '0', analog_pwr_squelch_xx_0_0_3, '0']
- [rational_resampler_xxx_0_0_4, '0', analog_pwr_squelch_xx_0_0_4, '0']
- [rational_resampler_xxx_0_0_4_0, '0', analog_pwr_squelch_xx_0_0_4_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
